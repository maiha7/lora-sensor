# IAR project Demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8L15x_StdPeriph_Driver\inc; Hardware
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Demo.hex
  ILINK.IlinkOutputFile: Demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Hardware
    Hardware/: ADC_N.c apply.c comconfig.c Crc8.c DriverConfig.c DriverConfig.h ds18b20.c flash.c gy3x.c iwdg.c led.c mq137.c sht2x.c sx1278.c tim2.c usart_t.c usart_t.h
  group STM8L15x_StdPeriph_Driver
    STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dac.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim2.c stm8l15x_tim4.c stm8l15x_usart.c
  group User
    ./: main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
    STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h

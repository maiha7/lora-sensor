<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>Hardware</name>
    <file>
      <name>$PROJ_DIR$\Hardware\ADC_N.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\apply.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\comconfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\Crc8.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\DriverConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\DriverConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\ds18b20.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\gy3x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\mq137.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\sht2x.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\sx1278.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\usart_t.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Hardware\usart_t.h</name>
    </file>
  </group>
  <group>
    <name>STM8L15x_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\src\stm8l15x_usart.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8L15x_StdPeriph_Driver\inc\stm8l15x.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8l15x_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8l15x_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\stm8l15x_it.h</name>
    </file>
  </group>
</project>


